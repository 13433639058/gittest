# Keil uVision project MS9331.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MS9331 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\cx32l003\Drivers\HW32L003_HAL_Driver\Inc;..\cx32l003\Drivers\CMSIS;..\cx32l003;..\HARDWARE\i2c;..\HARDWARE\uart;..\cx32l003\Drivers\CMSIS;..\cx32l003\Drivers\CMSIS\Device\XMC\HW32L003\Include;..\cx32l003\Drivers\CMSIS\Include;..\IR
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CX32L003
    ../cx32l003/: HW32l003_bsp.c HW32l003_it.c main.c
    ../cx32l003/Drivers/CMSIS/: system_HW32l003.c startup_HW32l003.s
  group HARDWARE
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/i2c/: i2c.c
  group CX32L003_HAL
    ../cx32l003/Drivers/HW32L003_HAL_Driver/Src/: HW32l003_hal.c HW32l003_hal_adc.c HW32l003_hal_awk.c HW32l003_hal_basetim.c HW32l003_hal_beep.c HW32l003_hal_clktrim.c HW32l003_hal_cortex.c HW32l003_hal_crc.c HW32l003_hal_flash.c HW32l003_hal_gpio.c HW32l003_hal_i2c.c HW32l003_hal_iwdg.c HW32l003_hal_lptim.c HW32l003_hal_lpuart.c HW32l003_hal_lvd.c HW32l003_hal_owire.c HW32l003_hal_pca.c HW32l003_hal_pwr.c HW32l003_hal_rcc.c HW32l003_hal_rtc.c HW32l003_hal_spi.c HW32l003_hal_tim.c HW32l003_hal_uart.c HW32l003_hal_vc.c HW32l003_hal_wwdg.c
  group IR
    ../IR/: IR_Receive.c
